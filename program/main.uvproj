# Keil uVision project main.uvproj, settings and files
target mian (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group src
    ./src/: delay.c LCD1602.C ds1302.c ADJUST.C ds18b20.C
  group main
    ./: main.c
